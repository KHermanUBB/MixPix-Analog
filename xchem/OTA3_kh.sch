v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} 90 -550 0 0 {name=p2 lab=IN_M
}
C {devices/ipin.sym} 90 -530 0 0 {name=p1 lab=IN_P}
C {devices/ipin.sym} 90 -510 0 0 {name=p3 lab=OUT}
C {devices/ipin.sym} 90 -570 0 0 {name=p9 lab=ibias}
C {devices/ipin.sym} 90 -490 0 0 {name=p4 lab=VDD}
C {devices/ipin.sym} 90 -470 0 0 {name=p5 lab=VSS}
